# IAR project proj1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: source\include; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: source; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: proj1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: source\include; include; $PROJ_DIR$
  group (top)
    ./: main.c
  group source
    source/: startup_stm32f10x_md.s stm32f10x_dma_dihalt.c stm32F10x_gpioMY.c stm32F10x_usart1.c system_stm32f10x.c
